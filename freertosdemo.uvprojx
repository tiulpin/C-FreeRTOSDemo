# Keil uVision project freertosdemo.uvprojx, settings and files
target FreeRTOSDemo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertosdemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c
  group inc
    ./inc/: includes.h
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Coroutines 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
